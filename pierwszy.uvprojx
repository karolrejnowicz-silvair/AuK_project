# Keil uVision project pierwszy.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pierwszy
  c flags: Optim=1 wLevel=2
  c include: .\STM32F401-Discovery\
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c lsm303dlhc.c lsm303dlhc.h gyro.h l3gd20.c l3gd20.h mag_accel.c tim_pwm.c tim_pwm_functions.c tim_pwm_functions.h tim_pwm.h app.c
    ./STM32F401-Discovery/: stm32f401_discovery.c stm32f401_discovery.h stm32f401_discovery_accelerometer.c stm32f401_discovery_accelerometer.h stm32f401_discovery_gyroscope.c stm32f401_discovery_gyroscope.h
  group ::Device
    RTE/Device/STM32F401VCTx/: RTE_Device.h startup_stm32f401xc.s stm32f4xx_hal_conf.h system_stm32f4xx.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
software components: CMSIS:CORE 3.40.0, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:I2C 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:TIM 1.1.0, Device:Startup 2.1.0
